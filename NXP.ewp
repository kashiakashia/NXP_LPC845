# IAR project NXP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC845M301 NXP LPC845M301
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: inc; peripherals_lib\inc; peripherals_lib\src; utilities_lib\inc; utilities_lib\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NXP.bin
  ILINK.IlinkOutputFile: NXP.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    peripherals_lib/src/: gpio.c Serial.c swm.c system.c
    ./: UART0_Terminal.c
    utilities_lib/src/: utilities.c
  group HAL_WS
    HAL_WS/: NXP_NVIC.c NXP_SPI_master.c NXP_Sys_Tik.c NXP_USART.c SPI0M_SPI1S.c
